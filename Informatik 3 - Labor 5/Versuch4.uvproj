# Keil uVision project Versuch4.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC1114/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Versuch4
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: main.c system_LPC11xx.c startup_LPC11xx.s spi.c picture.c
